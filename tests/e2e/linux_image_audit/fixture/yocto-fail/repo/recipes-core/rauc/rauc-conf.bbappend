FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://system.conf"
RAUC_KEYRING_FILE = "appliance-ca.cert.pem"
